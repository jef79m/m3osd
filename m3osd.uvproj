# Keil uVision project m3osd.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: m3osd +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: CoOS\portable;CoOS\kernel;lib\CMSIS\CM3\CoreSupport;lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;lib\STM32F10x_StdPeriph_Driver\inc;lib\STM32_USB-FS-Device_Driver\inc;src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./src/: board.h main.c fonts.c multiwii.c gps.c osdComponents.c
  group System
    ./lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c
    ./src/startup/: startup_stm32f10x_md.s
  group Drivers
    ./src/: usb_prop.c usb_pwr.c usb_endp.c usb_desc.c usb_istr.c sensors.h sensors.c osdcore.h osdcore.c uart.c uart.h usb.c rssi.c
  group USB
    ./lib/STM32_USB-FS-Device_Driver/src/: usb_regs.c usb_sil.c usb_core.c usb_init.c usb_int.c usb_mem.c
  group CoOS
    ./CoOS/kernel/: serviceReq.c time.c timer.c utility.c core.c flag.c hook.c kernelHeap.c mbox.c mm.c mutex.c task.c event.c queue.c sem.c OsConfig.h
    ./CoOS/portable/: arch.c
    ./CoOS/portable/Keil/: port.c
target STM32-Release (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: m3osd +hex
  c flags: Optim=4 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
